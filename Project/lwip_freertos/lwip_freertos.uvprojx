# Keil uVision project lwip_freertos.uvprojx, settings and files
target lwip_freertos (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: lwip_baremental +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ..\..\Library\CMSIS\Include;..\..\Library\CMSIS\Device\ST\STM32H7xx\Include;..\..\Library\STM32H7xx_HAL_Driver\Inc;..\..\Library\LwIP\include;..\..\Library\LwIP\include\lwip\apps;..\..\Library\LwIP\include\lwip\priv;..\..\Library\LwIP\include\lwip\prot;..\..\Library\LwIP\include\lwip;..\..\User\bsp_common\delay;..\..\User\bsp_common\sys;..\..\User\bsp_common\mpu_bsp;..\..\User\bsp_common\key_bsp;..\..\User\bsp_common\led_bsp;..\..\User\bsp_common\led_bsp;..\..\User\bsp_common\PCF8574;..\..\User\bsp_common\uart_bsp;..\..\User\fw_lwip_freertos;..\..\User\fw_lwip_freertos\eth_bsp;..\..\User\fw_lwip_freertos\timer_bsp;..\..\User\fw_lwip_freertos\LwIP_arch;..\..\Library\FreeRTOS\include;..\..\Library\FreeRTOS\portable\RVDS\ARM_CM7\r0p1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group startup
    ../../Library/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group cmsis
    ../../Library/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group stm32h7xx_hal_drvier
    ../../Library/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group user
    ../../User/bsp_common/delay/: core_delay.c
    ../../User/bsp_common/sys/: sys.c
    ../../User/fw_lwip_freertos/: main.c stm32h7xx_it.c
  group bsp
    ../../User/bsp_common/key_bsp/: key_bsp.c
    ../../User/bsp_common/led_bsp/: led_bsp.c
    ../../User/bsp_common/PCF8574/: myiic.c pcf8574.c
    ../../User/bsp_common/uart_bsp/: usart_bsp.c
    ../../User/bsp_common/mpu_bsp/: mpu_bsp.c
    ../../User/fw_lwip_freertos/timer_bsp/: timer_bsp.c
  group eth
    ../../User/fw_lwip_freertos/LwIP_arch/: app_ethernet.c ethernetif.c sys_arch.c
    ../../User/fw_lwip_freertos/eth_bsp/: LAN8720a.c
  group LwIP/api
    ../../Library/LwIP/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/core
    ../../Library/LwIP/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../Library/LwIP/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LwIP/netif
    ../../Library/LwIP/netif/: ethernet.c
  group FreeRTOS/src
    ../../Library/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../Library/FreeRTOS/portable/MemMang/: heap_4.c
    ../../Library/FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
